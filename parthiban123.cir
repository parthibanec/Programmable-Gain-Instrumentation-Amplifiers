* C:\neww\parthiban123\parthiban123.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 10/8/2022 11:20:45 PM

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
X2  Net-_U1-Pad7_ Net-_X2-Pad2_ Net-_U1-Pad7_ IN1 Net-_SC1-Pad1_ GND avsd_opamp
X3  Net-_SC1-Pad1_ Net-_X3-Pad2_ Net-_SC1-Pad1_ Net-_SC7-Pad2_ OUT1 GND avsd_opamp
X1  Net-_U2-Pad7_ Net-_X1-Pad2_ Net-_U2-Pad7_ IN2 Net-_SC7-Pad2_ GND avsd_opamp
U1  Net-_SC3-Pad2_ Net-_SC2-Pad2_ Net-_SC1-Pad2_ Net-_SC1-Pad1_ GND GND Net-_U1-Pad7_ mux61
U2  Net-_SC7-Pad2_ Net-_SC6-Pad2_ Net-_SC5-Pad2_ Net-_SC4-Pad2_ GND GND Net-_U2-Pad7_ mux61
v2  Net-_U1-Pad7_ GND DC
v5  GND Net-_X2-Pad2_ DC
v4  IN1 GND sine
v1  Net-_U2-Pad7_ GND DC
v3  IN2 GND sine
v6  GND Net-_X1-Pad2_ DC
SC1  Net-_SC1-Pad1_ Net-_SC1-Pad2_ Net-_SC1-Pad3_ sky130_fd_pr__res_generic_pd
SC2  Net-_SC1-Pad2_ Net-_SC2-Pad2_ Net-_SC1-Pad3_ sky130_fd_pr__res_generic_pd
SC3  Net-_SC2-Pad2_ Net-_SC3-Pad2_ Net-_SC1-Pad3_ sky130_fd_pr__res_generic_pd
SC4  Net-_SC3-Pad2_ Net-_SC4-Pad2_ Net-_SC1-Pad3_ sky130_fd_pr__res_generic_pd
SC5  Net-_SC4-Pad2_ Net-_SC5-Pad2_ Net-_SC1-Pad3_ sky130_fd_pr__res_generic_pd
SC6  Net-_SC5-Pad2_ Net-_SC6-Pad2_ Net-_SC1-Pad3_ sky130_fd_pr__res_generic_pd
SC7  Net-_SC6-Pad2_ Net-_SC7-Pad2_ Net-_SC1-Pad3_ sky130_fd_pr__res_generic_pd
v7  Net-_SC1-Pad1_ GND DC
v8  GND Net-_X3-Pad2_ DC
U3  OUT1 ? adc_bridge_1
scmode1  SKY130mode
U5  IN1 plot_v1
U4  IN2 plot_v1

.end
